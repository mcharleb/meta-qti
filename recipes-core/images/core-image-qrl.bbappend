
PACKAGE_GROUP_boot = "lk"
IMAGE_FEATURES += "boot" 
